FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://no-faulty.cfg \
            file://debug-on.cfg \
           "
